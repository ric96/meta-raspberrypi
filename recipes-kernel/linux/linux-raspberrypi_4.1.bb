LINUX_VERSION ?= "4.1.0"

SRCREV = "f6f3129ad7b49499004510b6a252f222c029efcb"
SRC_URI = "git://github.com/raspberrypi/linux.git;protocol=git;branch=rpi-4.4.y"

require linux-raspberrypi.inc
